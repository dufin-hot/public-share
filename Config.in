## package/ssv6x5x/Config.in
```kconfig
config BR2_PACKAGE_SSV6X5X
	bool "ssv6x5x"
	depends on BR2_LINUX_KERNEL
	help
	  SSV6256P / SSV6X5X SDIO Wi-Fi driver.
```
